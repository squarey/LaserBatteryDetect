# IAR project LaserBatteryDetect.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\Includes; ..\Libraries\STM8S_StdPeriph_Driver\inc; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LaserBatteryDetect.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Hardware/adc
    ../Hardware/adc/: adc.c
  group Hardware/control
    ../Hardware/control/: control.c
  group Hardware/flash
    ../Hardware/flash/: flash.c
  group Hardware/timer
    ../Hardware/timer/: timer.c
  group Hardware/watchdog
    ../Hardware/watchdog/: watchdog.c
  group Includes
    ../Includes/: adc.h control.h delay.h flash.h sys.h temperature_table.h timer.h uart.h watchdog.h
  group Libraries/STM8S_StdPeriph_Driver
    ../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
  group System/delay
    ../System/delay/: delay.c
  group System/sys
    ../System/sys/: sys.c
  group System/uart
    ../System/uart/: uart.c
  group User
    ./: main.c stm8s_conf.h stm8s_it.h
